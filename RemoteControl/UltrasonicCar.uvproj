# Keil uVision project UltrasonicCar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: UltrasonicCar +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Delay;.\INSend;.\Main;.\Uart;.\ADC
  group Source Group 1
    ./: STARTUP.A51
  group Main
    ./Main/: main.c
  group Uart
    ./Uart/: Uart.c
  group INSend
    ./INSend/: INSend.c
  group Delay
    ./Delay/: delay.c
  group ADC
    ./ADC/: ADC.c
