# Keil uVision project UltrasonicCar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: UltrasonicCar +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Delay;.\HCSR04;.\Motor;.\Uart
  group Source Group 1
    ./: STARTUP.A51
  group Main
    ./Main/: main.c
  group Motor
    ./Motor/: Motor.c
  group Uart
    ./Uart/: Uart.c
  group HCSR04
    ./HCSR04/: HCSR04.c
  group Delay
    ./Delay/: delay.c
