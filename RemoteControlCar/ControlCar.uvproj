# Keil uVision project ControlCar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: ControlCar +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Delay;.\INRecv;.\Motor;.\Uart
  group Source Group 1
    ./: STARTUP.A51
  group Main
    ./Main/: main.c
  group Uart
    ./Uart/: Uart.c
  group Motor
    ./Motor/: Motor.c
  group INRecv
    ./INRecv/: INRecv.c
  group Delay
    ./Delay/: delay.c
